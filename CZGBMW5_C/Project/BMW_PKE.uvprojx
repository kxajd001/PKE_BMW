# Keil uVision project BMW_PKE.uvprojx, settings and files
target BMW5NEW (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CZG_BMW5_C_3LFOUT +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CMSIS\include;..\Drv_drivers\include;..\STM32F10x_StdPeriph_Driver\inc;..\User\Include
  memory RVCT4: ROM 0x8003000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ../StartUp/: startup_stm32f10x_cl.s
  group CMSIS
    ../CMSIS/source/: core_cm3.c system_stm32f10x.c
  group drivers
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_iwdg.c
  group Drv_drivers
    ../Drv_drivers/source/: Drv_CAN.c Drv_Time.c Drv_SPI.c Drv_Cmt2300.c Drv_Serial.c
  group APP
    ../User/Source/: main.c stm32f10x_it.c UHF_125K.c App_flash.c App_command.c App_iap.c App_uart.c
